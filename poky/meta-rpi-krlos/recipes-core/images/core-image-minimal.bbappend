IMAGE_INSTALL:append = " \
    nano \
    htop \
    iproute2 \
    procps \
    less \
    which \
    file \
    iputils \
"
